# Keil uVision project STM32SF0_Pro_Mode.uvprojx, settings and files
target STM32_Pro_Mode (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32SF0_Pro_Mode
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F030,USE_STDPERIPH_DRIVER
  c include: ..\App;..\Core;..\Lib\inc;..\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Core
    ../Core/: startup_stm32f030.s
  group Lib
    ../Lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_syscfg.c
  group User
    ../User/: main.c stm32f0xx_it.c system_stm32f0xx.c
