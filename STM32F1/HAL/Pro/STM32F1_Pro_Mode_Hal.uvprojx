# Keil uVision project STM32F1_Pro_Mode_Hal.uvprojx, settings and files
target STM32F1_Pro_Mode_Hal (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1_Pro_Mode_Hal +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE,USE_HAL_DRIVER
  c include: ..\APP;..\STM32HAL_Lib\Core;..\STM32HAL_Lib\Inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../STM32HAL_Lib/Core/: system_stm32f1xx.c startup_stm32f103xe.s
  group HAL_LIB
    ../STM32HAL_Lib/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c
  group USER
    ../USER/: main.c stm32f1xx_it.c
  group Doc
    ../Doc/: readme.txt
