# Keil uVision project STM32F1_Pro_Mode.uvprojx, settings and files
target STM32F1_Pro_Mode_Std (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1_Pro_Mode +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\USER;..\STM32Lib\core;..\STM32Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../STM32Lib/core/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group LIB
    ../STM32Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group USER
    ../USER/: main.c stm32f10x_it.c
